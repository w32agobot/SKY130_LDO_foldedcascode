v {xschem version=3.4.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 1010 -1630 1010 -1600 {}
L 4 1000 -1600 1010 -1600 {}
L 4 1000 -1600 1000 -1560 {}
L 4 1000 -1560 1010 -1560 {}
L 4 1010 -1560 1010 -1530 {}
L 4 1090 -1630 1090 -1600 {}
L 4 1090 -1600 1100 -1600 {}
L 4 1100 -1600 1100 -1560 {}
L 4 1090 -1560 1100 -1560 {}
L 4 1090 -1560 1090 -1530 {}
L 4 990 -1600 990 -1560 {}
L 4 1110 -1600 1110 -1560 {}
L 4 1110 -1560 1120 -1560 {}
L 4 980 -1560 990 -1560 {}
L 4 1010 -1460 1010 -1430 {}
L 4 1000 -1430 1010 -1430 {}
L 4 1000 -1430 1000 -1390 {}
L 4 1000 -1390 1010 -1390 {}
L 4 1010 -1390 1010 -1360 {}
L 4 1090 -1460 1090 -1430 {}
L 4 1090 -1430 1100 -1430 {}
L 4 1100 -1430 1100 -1390 {}
L 4 1090 -1390 1100 -1390 {}
L 4 1090 -1390 1090 -1360 {}
L 4 990 -1430 990 -1390 {}
L 4 1110 -1430 1110 -1390 {}
L 4 1110 -1390 1120 -1390 {}
L 4 980 -1390 990 -1390 {}
L 4 1010 -1290 1010 -1260 {}
L 4 1000 -1260 1010 -1260 {}
L 4 1000 -1260 1000 -1220 {}
L 4 1000 -1220 1010 -1220 {}
L 4 1010 -1220 1010 -1190 {}
L 4 1090 -1290 1090 -1260 {}
L 4 1090 -1260 1100 -1260 {}
L 4 1100 -1260 1100 -1220 {}
L 4 1090 -1220 1100 -1220 {}
L 4 1090 -1220 1090 -1190 {}
L 4 990 -1260 990 -1220 {}
L 4 1110 -1260 1110 -1220 {}
L 4 1110 -1220 1120 -1220 {}
L 4 980 -1220 990 -1220 {}
L 4 1010 -1110 1010 -1080 {}
L 4 1000 -1080 1010 -1080 {}
L 4 1000 -1080 1000 -1040 {}
L 4 1000 -1040 1010 -1040 {}
L 4 1010 -1040 1010 -1010 {}
L 4 1090 -1110 1090 -1080 {}
L 4 1090 -1080 1100 -1080 {}
L 4 1100 -1080 1100 -1040 {}
L 4 1090 -1040 1100 -1040 {}
L 4 1090 -1040 1090 -1010 {}
L 4 990 -1080 990 -1040 {}
L 4 1110 -1080 1110 -1040 {}
L 4 1110 -1040 1120 -1040 {}
L 4 980 -1040 990 -1040 {}
L 4 1010 -1190 1010 -1110 {}
L 4 1090 -1190 1090 -1110 {}
L 4 1010 -1360 1010 -1290 {}
L 4 1090 -1360 1090 -1290 {}
L 4 1010 -1530 1010 -1460 {}
L 4 1090 -1520 1090 -1460 {}
L 4 1090 -1530 1090 -1520 {}
L 4 1010 -1690 1090 -1690 {}
L 4 1050 -1750 1050 -1690 {}
L 4 1040 -1740 1050 -1750 {}
L 4 1050 -1750 1060 -1740 {}
L 4 1010 -1010 1090 -1010 {}
L 4 1050 -1010 1050 -970 {}
L 4 1040 -970 1060 -970 {}
L 4 950 -1040 980 -1040 {}
L 4 950 -1310 950 -1040 {}
L 4 950 -1310 1010 -1310 {}
L 4 910 -1220 980 -1220 {}
L 4 910 -1040 950 -1040 {}
L 4 910 -1390 980 -1390 {}
L 4 910 -1560 980 -1560 {}
L 4 1120 -1560 1190 -1560 {}
L 4 1120 -1390 1190 -1390 {}
L 4 1120 -1220 1190 -1220 {}
L 4 1120 -1040 1190 -1040 {}
L 4 1090 -1690 1090 -1630 {}
L 4 1010 -1690 1010 -1630 {}
L 4 1010 -1630 1020 -1640 {}
L 4 1000 -1640 1010 -1630 {}
L 4 1090 -1630 1100 -1640 {}
L 4 1080 -1640 1090 -1630 {}
L 4 2340 -1620 2340 -1590 {}
L 4 2330 -1590 2340 -1590 {}
L 4 2330 -1590 2330 -1550 {}
L 4 2330 -1550 2340 -1550 {}
L 4 2340 -1550 2340 -1520 {}
L 4 2420 -1620 2420 -1590 {}
L 4 2420 -1590 2430 -1590 {}
L 4 2430 -1590 2430 -1550 {}
L 4 2420 -1550 2430 -1550 {}
L 4 2420 -1550 2420 -1520 {}
L 4 2320 -1590 2320 -1550 {}
L 4 2440 -1590 2440 -1550 {}
L 4 2440 -1550 2450 -1550 {}
L 4 2310 -1550 2320 -1550 {}
L 4 2340 -1450 2340 -1420 {}
L 4 2330 -1420 2340 -1420 {}
L 4 2330 -1420 2330 -1380 {}
L 4 2330 -1380 2340 -1380 {}
L 4 2340 -1380 2340 -1350 {}
L 4 2420 -1450 2420 -1420 {}
L 4 2420 -1420 2430 -1420 {}
L 4 2430 -1420 2430 -1380 {}
L 4 2420 -1380 2430 -1380 {}
L 4 2420 -1380 2420 -1350 {}
L 4 2320 -1420 2320 -1380 {}
L 4 2440 -1420 2440 -1380 {}
L 4 2440 -1380 2450 -1380 {}
L 4 2310 -1380 2320 -1380 {}
L 4 2340 -1280 2340 -1250 {}
L 4 2330 -1250 2340 -1250 {}
L 4 2330 -1250 2330 -1210 {}
L 4 2330 -1210 2340 -1210 {}
L 4 2340 -1210 2340 -1180 {}
L 4 2420 -1280 2420 -1250 {}
L 4 2420 -1250 2430 -1250 {}
L 4 2430 -1250 2430 -1210 {}
L 4 2420 -1210 2430 -1210 {}
L 4 2420 -1210 2420 -1180 {}
L 4 2320 -1250 2320 -1210 {}
L 4 2440 -1250 2440 -1210 {}
L 4 2440 -1210 2450 -1210 {}
L 4 2310 -1210 2320 -1210 {}
L 4 2340 -1100 2340 -1070 {}
L 4 2330 -1070 2340 -1070 {}
L 4 2330 -1070 2330 -1030 {}
L 4 2330 -1030 2340 -1030 {}
L 4 2340 -1030 2340 -1000 {}
L 4 2420 -1100 2420 -1070 {}
L 4 2420 -1070 2430 -1070 {}
L 4 2430 -1070 2430 -1030 {}
L 4 2420 -1030 2430 -1030 {}
L 4 2420 -1030 2420 -1000 {}
L 4 2320 -1070 2320 -1030 {}
L 4 2440 -1070 2440 -1030 {}
L 4 2440 -1030 2450 -1030 {}
L 4 2310 -1030 2320 -1030 {}
L 4 2340 -1180 2340 -1100 {}
L 4 2420 -1180 2420 -1100 {}
L 4 2340 -1350 2340 -1280 {}
L 4 2420 -1350 2420 -1280 {}
L 4 2340 -1520 2340 -1450 {}
L 4 2420 -1510 2420 -1450 {}
L 4 2420 -1520 2420 -1510 {}
L 4 2340 -1680 2420 -1680 {}
L 4 2380 -1740 2380 -1680 {}
L 4 2370 -1730 2380 -1740 {}
L 4 2380 -1740 2390 -1730 {}
L 4 2340 -1000 2420 -1000 {}
L 4 2380 -1000 2380 -960 {}
L 4 2370 -960 2390 -960 {}
L 4 2280 -1030 2310 -1030 {}
L 4 2280 -1300 2280 -1030 {}
L 4 2280 -1300 2340 -1300 {}
L 4 2240 -1210 2310 -1210 {}
L 4 2240 -1030 2280 -1030 {}
L 4 2240 -1380 2310 -1380 {}
L 4 2240 -1550 2310 -1550 {}
L 4 2450 -1550 2520 -1550 {}
L 4 2450 -1380 2520 -1380 {}
L 4 2450 -1210 2520 -1210 {}
L 4 2450 -1030 2520 -1030 {}
L 4 2420 -1680 2420 -1620 {}
L 4 2340 -1680 2340 -1620 {}
L 4 2340 -1620 2350 -1630 {}
L 4 2330 -1630 2340 -1620 {}
L 4 2420 -1620 2430 -1630 {}
L 4 2410 -1630 2420 -1620 {}
L 4 2340 -1340 2360 -1350 {}
L 4 2320 -1350 2340 -1340 {}
L 4 2420 -1340 2440 -1350 {}
L 4 2400 -1350 2420 -1340 {}
L 4 2910 -1520 2910 -1480 {}
L 4 2850 -1500 2850 -1480 {}
L 4 2850 -1480 2850 -1440 {}
L 4 2840 -1440 2850 -1440 {}
L 4 2840 -1440 2840 -1400 {}
L 4 2840 -1400 2850 -1400 {}
L 4 2850 -1400 2850 -1380 {}
L 4 2850 -1380 2910 -1380 {}
L 4 2910 -1400 2910 -1380 {}
L 4 2910 -1400 2920 -1400 {}
L 4 2920 -1440 2920 -1400 {}
L 4 2910 -1440 2920 -1440 {}
L 4 2910 -1480 2910 -1440 {}
L 4 2930 -1440 2930 -1400 {}
L 4 2930 -1400 2940 -1400 {}
L 4 2830 -1440 2830 -1400 {}
L 4 2820 -1400 2830 -1400 {}
L 4 2800 -1530 2810 -1520 {}
L 4 2800 -1510 2810 -1520 {}
L 4 2810 -1510 2820 -1500 {}
L 4 2810 -1490 2820 -1500 {}
L 4 2340 -1520 2910 -1520 {}
L 4 2420 -1500 2850 -1500 {}
L 4 2880 -1380 2880 -1350 {}
L 4 2880 -1350 2890 -1350 {}
L 4 2890 -1350 2890 -1320 {}
L 4 2880 -1320 2890 -1320 {}
L 4 2880 -1320 2880 -1290 {}
L 4 2860 -1290 2900 -1290 {}
L 4 2900 -1350 2900 -1320 {}
L 4 2900 -1320 2910 -1320 {}
L 4 1090 -1310 1160 -1310 {}
L 4 80 -3220 80 -2780 {}
L 4 100 -2780 700 -2780 {}
L 4 100 -3220 700 -3220 {}
L 4 700 -3220 700 -2780 {}
L 4 80 -3220 100 -3220 {}
L 4 80 -2780 100 -2780 {}
L 4 880 -920 1320 -920 {}
L 4 880 -920 880 -480 {}
L 4 880 -480 1320 -480 {}
L 4 1320 -920 1320 -480 {}
L 4 80 -2740 80 -2300 {}
L 4 100 -2300 700 -2300 {}
L 4 100 -2740 700 -2740 {}
L 4 700 -2740 700 -2300 {}
L 4 80 -2740 100 -2740 {}
L 4 80 -2300 100 -2300 {}
L 4 80 -2260 80 -1820 {}
L 4 100 -1820 700 -1820 {}
L 4 100 -2260 700 -2260 {}
L 4 700 -2260 700 -1820 {}
L 4 80 -2260 100 -2260 {}
L 4 80 -1820 100 -1820 {}
L 4 1010 -1500 1160 -1500 {}
L 4 1090 -1480 1160 -1480 {}
B 2 500 -1670 890 -1530 {flags=graph
y1=-0.11
y2=0.32
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color="8 9"
node="\\"MP1 Vds-Vsat;@m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[vds] @m.x1.x1.xmp1.msky130_fd_pr__pfet_01v8_lvt[vdsat] -\\"
\\"VDS;@m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[vds]\\""}
B 2 1210 -1670 1590 -1530 {flags=graph
y1=-0.091
y2=0.34
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color="8 9"
node="\\"MP2 Vds-Vsat;@m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[vds] @m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[vdsat] -\\"
\\"VDS;@m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[vds]\\""}
B 2 500 -1490 890 -1350 {flags=graph
y1=0.77
y2=0.97
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color=8
node="\\"MP3 Vds-Vsat;@m.x1.x1.xmp3.msky130_fd_pr__pfet_01v8_lvt[vds] @m.x1.x1.xmp3.msky130_fd_pr__pfet_01v8_lvt[vdsat] -\\""}
B 2 1210 -1490 1590 -1350 {flags=graph
y1=-0.19
y2=1.6
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color=8
node="\\"MP4 Vds-Vsat;@m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[vds] @m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[vdsat] -\\""}
B 2 500 -1300 890 -1160 {flags=graph
y1=0.15
y2=0.41
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color=8
node="\\"MN3 Vds-Vsat;@m.x1.x1.xmn3.msky130_fd_pr__nfet_01v8_lvt[vds] @m.x1.x1.xmn3.msky130_fd_pr__nfet_01v8_lvt[vdsat] -\\""}
B 2 1210 -1300 1590 -1160 {flags=graph
y1=-0.22
y2=1.5
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color=8
node="\\"MN4 Vds-Vsat;@m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[vds] @m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[vdsat] -\\""}
B 2 500 -1120 890 -980 {flags=graph
y1=0.12
y2=0.31
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color="8 9"
node="\\"MN6 Vds-Vsat;@m.x1.x1.xmn6.msky130_fd_pr__nfet_01v8[vds] @m.x1.x1.xmn6.msky130_fd_pr__nfet_01v8[vdsat] -\\"
\\"VDS;@m.x1.x1.xmn6.msky130_fd_pr__nfet_01v8[vds]\\""}
B 2 1210 -1120 1590 -980 {flags=graph
y1=-0.13
y2=0.32
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color="8 9"
node="\\"MN7 Vds-Vsat;@m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[vds] @m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[vdsat] -\\"
\\"VDS;@m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[vds]\\""}
B 2 1610 -1670 1990 -1530 {flags=graph
y1=0.061
y2=0.092
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color=11
node="\\"MP2 Vov;@m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[vgs] @m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[vth] -\\""}
B 2 1610 -1490 1990 -1350 {flags=graph
y1=-0.25
y2=0.19
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color=11
node="\\"MP4 Vov;@m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[vgs] @m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[vth] -\\""}
B 2 1610 -1300 1990 -1160 {flags=graph
y1=-0.21
y2=0.23
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color=11
node="\\"MN4 Vov;@m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[vgs] @m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[vth] -\\""}
B 2 1610 -1120 1990 -980 {flags=graph
y1=-0.045
y2=0.13
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color=11
node="\\"MN7 Vov;@m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[vgs] @m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[vth] -\\""}
B 2 80 -1670 470 -1530 {flags=graph
y1=0.061
y2=0.092
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color=11
node="\\"MP1 Vov;@m.x1.x1.xmp1.msky130_fd_pr__pfet_01v8_lvt[vgs] @m.x1.x1.xmp1.msky130_fd_pr__pfet_01v8_lvt[vth] -\\""}
B 2 80 -1490 470 -1350 {flags=graph
y1=-0.25
y2=-0.11
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color=11
node="\\"MP3 Vov;@m.x1.x1.xmp3.msky130_fd_pr__pfet_01v8_lvt[vgs] @m.x1.x1.xmp3.msky130_fd_pr__pfet_01v8_lvt[vth] -\\""}
B 2 80 -1300 470 -1160 {flags=graph
y1=-0.2
y2=-0.1
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color=11
node="\\"MN3 Vov;@m.x1.x1.xmn3.msky130_fd_pr__nfet_01v8_lvt[vgs] @m.x1.x1.xmn3.msky130_fd_pr__nfet_01v8_lvt[vth] -\\""}
B 2 80 -1120 470 -980 {flags=graph
y1=-0.045
y2=0.049
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color=11
node="\\"MN6 Vov;@m.x1.x1.xmn6.msky130_fd_pr__nfet_01v8[vgs] @m.x1.x1.xmn6.msky130_fd_pr__nfet_01v8[vth] -\\""}
B 2 2130 -1740 2270 -1600 {flags=graph
y1=3.6e-07
y2=8.4e-07
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color=12
node=i(@m.x1.x1.xmp1.msky130_fd_pr__pfet_01v8_lvt[id])}
B 2 2470 -1740 2610 -1600 {flags=graph
y1=1e-07
y2=8.4e-07
ypos1=0
ypos2=2
divy=10
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color=6
node=i(@m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[id])}
B 2 2480 -1360 2660 -1220 {flags=graph
y1=1e-07
y2=5.3e-07
ypos1=0
ypos2=2
divy=10
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color=6
node=i(@m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[id])}
B 2 2090 -1370 2270 -1220 {flags=graph
y1=1e-07
y2=8.3e-07
ypos1=0
ypos2=2
divy=10
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color=12
node=i(@m.x1.x1.xmp3.msky130_fd_pr__pfet_01v8_lvt[id])}
B 2 2770 -1680 2910 -1540 {flags=graph
y1=4.9e-10
y2=6.1e-07
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color="12 6"
node="\\"MN1 i(inp);i(@m.x1.x1.xmn1.msky130_fd_pr__nfet_01v8_lvt[id])\\"
\\"MN2 i(inn);i(@m.x1.x1.xmn2.msky130_fd_pr__nfet_01v8_lvt[id])\\""}
B 2 80 -880 470 -720 {flags=graph
y1=6.7e-07
y2=1.6e-05
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0

color="7 4"
node="\\"MP4 gm;@m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[gm]\\"
\\"MN4 gm;@m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[gm]\\""}
B 2 1380 -3220 1960 -2820 {flags=graph,unlocked
y1=3.36412
y2=234.28
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=5.55112e-17
x2=7
divx=5
subdivx=8
node="\\"Phase (deg);ph(out_ac)\\""
color=4
dataset=-1
unitx=1
logx=1
logy=0
}
B 2 1410 -880 1990 -480 {flags=graph
y1=0.017
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1
node=out
color=4
dataset=-1
unitx=1
logx=0
logy=0
}
B 2 760 -3220 1340 -2820 {flags=graph,unlocked
y1=-13
y2=73
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-5.55112e-17
x2=7
divx=5
subdivx=8
node="\\"Open Loop Gain A0 (dB);out_ac db20()\\""
color=4
dataset=-1
unitx=1
logx=1
logy=0
}
B 2 760 -2740 1340 -2340 {flags=graph,unlocked
y1=21
y2=130
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=7
divx=5
subdivx=8
node="\\"CMRR (dB) A0/Acm;out_ac db20() out_cmrr db20() -\\""
color=4
dataset=-1
unitx=1
logx=1
logy=0
}
B 2 760 -2260 1340 -1860 {flags=graph,unlocked
y1=23
y2=89
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=7
divx=5
subdivx=8
node="\\"PSRR (dB);0 out_psrr db20() -\\""
color=4
dataset=-1
unitx=1
logx=1
logy=0
}
B 2 2980 -1540 3220 -1400 {flags=graph
y1=0.89
y2=1.4
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color="7 8"
node="\\"MN1 Vds-Vsat;@m.x1.x1.xmn1.msky130_fd_pr__nfet_01v8_lvt[vds] @m.x1.x1.xmn1.msky130_fd_pr__nfet_01v8_lvt[vdsat] -\\"
\\"MN2 Vds-Vsat;@m.x1.x1.xmn2.msky130_fd_pr__nfet_01v8_lvt[vds] @m.x1.x1.xmn2.msky130_fd_pr__nfet_01v8_lvt[vdsat] -\\""}
B 2 3230 -1540 3450 -1400 {flags=graph
y1=-0.32
y2=-0.088
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color="11 8"
node="\\"MN1 Vov;@m.x1.x1.xmn1.msky130_fd_pr__nfet_01v8_lvt[vgs] @m.x1.x1.xmn1.msky130_fd_pr__nfet_01v8_lvt[vth] -\\"
\\"MN2 Vov;@m.x1.x1.xmn2.msky130_fd_pr__nfet_01v8_lvt[vgs] @m.x1.x1.xmn2.msky130_fd_pr__nfet_01v8_lvt[vth] -\\""}
B 2 2980 -1360 3220 -1220 {flags=graph
y1=0.24
y2=0.4
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color=7
node="\\"MN5 Vds-Vsat;@m.x1.x1.xmn5.msky130_fd_pr__nfet_01v8[vds] @m.x1.x1.xmn5.msky130_fd_pr__nfet_01v8[vdsat] -\\""}
B 2 3230 -1360 3450 -1220 {flags=graph
y1=-0.0043
y2=0.024
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color=11
node="\\"MN5 Vov;@m.x1.x1.xmn5.msky130_fd_pr__nfet_01v8[vgs] @m.x1.x1.xmn5.msky130_fd_pr__nfet_01v8[vth] -\\""}
B 2 2100 -750 2360 -620 {flags=graph
y1=1.5
y2=1.8
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color=9
node="\\"Voutmax = vbias2 + vth + vdsat - vdsat;x1.bias2 @m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[vth] +\\""}
B 2 2100 -600 2360 -480 {flags=graph
y1=0.11
y2=0.23
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0

color=9
node="\\"Voutmin = vbias3 + vth + vdsat - vdsat;x1.bias3 @m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[vth] -\\""}
B 2 1480 -1990 1870 -1850 {flags=graph
y1=0.34
y2=0.69
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.2
x2=0.2
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0
color="4 6 7 9"
node="\\"MN4;@m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[vth]\\"
\\"MN14;@m.x1.x1.xmn14.msky130_fd_pr__nfet_01v8_lvt[vth]\\"
\\"MP4;@m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[vth]\\"
\\"MP6;@m.x1.x1.xmp6.msky130_fd_pr__pfet_01v8_lvt[vth]\\""}
T {   Copyright 2022 Manuel Moser

   Licensed under the Apache License, Version 2.0 (the "License");
   you may not use this file except in compliance with the License.
   You may obtain a copy of the License at

       http://www.apache.org/licenses/LICENSE-2.0

   Unless required by applicable law or agreed to in writing, software
   distributed under the License is distributed on an "AS IS" BASIS,
   WITHOUT WARRANTIES OR CONDITIONS OF ANY KIND, either express or implied.
   See the License for the specific language governing permissions and
   limitations under the License.} 0 -240 0 0 0.2 0.2 {}
T {p} 1010 -1580 0 0 0.2 0.2 {}
T {p} 1090 -1580 0 0 0.2 0.2 {}
T {p} 1010 -1410 0 0 0.2 0.2 {}
T {p} 1090 -1410 0 0 0.2 0.2 {}
T {n} 1010 -1240 0 0 0.2 0.2 {}
T {n} 1090 -1240 0 0 0.2 0.2 {}
T {n} 1010 -1060 0 0 0.2 0.2 {}
T {n} 1090 -1060 0 0 0.2 0.2 {}
T {VDS-VSAT SATURATION} 500 -1520 0 0 0.4 0.4 {}
T {VDS-VSAT SATURATION} 1210 -1520 0 0 0.4 0.4 {}
T {VDS-VSAT SATURATION} 500 -1700 0 0 0.4 0.4 {}
T {VDS-VSAT SATURATION} 1210 -1700 0 0 0.4 0.4 {}
T {VDS-VSAT SATURATION} 500 -1150 0 0 0.4 0.4 {}
T {VDS-VSAT SATURATION} 1210 -1150 0 0 0.4 0.4 {}
T {VDS-VSAT SATURATION} 500 -1330 0 0 0.4 0.4 {}
T {VDS-VSAT SATURATION} 1210 -1330 0 0 0.4 0.4 {}
T {VGS-VTH} 1610 -1520 0 0 0.4 0.4 {}
T {VGS-VTH} 1610 -1700 0 0 0.4 0.4 {}
T {VGS-VTH} 1610 -1150 0 0 0.4 0.4 {}
T {VGS-VTH} 1610 -1330 0 0 0.4 0.4 {}
T {VGS-VTH} 80 -1520 0 0 0.4 0.4 {}
T {VGS-VTH} 80 -1700 0 0 0.4 0.4 {}
T {VGS-VTH} 80 -1150 0 0 0.4 0.4 {}
T {VGS-VTH} 80 -1330 0 0 0.4 0.4 {}
T {p} 2340 -1570 0 0 0.2 0.2 {}
T {p} 2420 -1570 0 0 0.2 0.2 {}
T {p} 2340 -1400 0 0 0.2 0.2 {}
T {p} 2420 -1400 0 0 0.2 0.2 {}
T {n} 2340 -1230 0 0 0.2 0.2 {}
T {n} 2420 -1230 0 0 0.2 0.2 {}
T {n} 2340 -1050 0 0 0.2 0.2 {}
T {n} 2420 -1050 0 0 0.2 0.2 {}
T {INP} 2950 -1450 2 0 0.4 0.4 {}
T {INN} 2840 -1450 2 0 0.4 0.4 {}
T {MP4} 1100 -1380 0 0 0.2 0.2 {}
T {MN4} 1100 -1210 0 0 0.2 0.2 {}
T {GM of MP4 and MN4} 80 -910 0 0 0.4 0.4 {}
T {VDD=0.85-1.9V} 40 -440 0 0 0.6 0.6 {}
T {AC open loop Gain A0} 120 -3200 0 0 0.4 0.4 {}
T {DC} 920 -900 0 0 0.4 0.4 {}
T {CMRR} 120 -2720 0 0 0.4 0.4 {}
T {PSRR} 120 -2240 0 0 0.4 0.4 {}
T {VDS-VSAT} 2980 -1570 0 0 0.4 0.4 {}
T {VGS-VTH} 3230 -1570 0 0 0.4 0.4 {}
T {VDS-VSAT} 2980 -1390 0 0 0.4 0.4 {}
T {VGS-VTH} 3230 -1390 0 0 0.4 0.4 {}
T {MN1} 2800 -1400 3 0 0.4 0.4 {}
T {MN2} 2940 -1400 3 0 0.4 0.4 {}
T {Output Swing} 2070 -530 3 0 0.4 0.4 {}
T {darf nicht 0 werden >} 2120 -1040 3 0 0.3 0.3 {}
T {1VOV} 970 -1110 0 0 0.2 0.2 {}
T {VTH+1VOV} 940 -1330 0 0 0.2 0.2 {}
T {Threshold Voltages} 1480 -2020 0 0 0.4 0.4 {}
N 1030 -700 1050 -700 {
lab=inp}
N 1030 -660 1050 -660 {
lab=inn}
N 520 -500 520 -480 {
lab=VSS}
N 340 -500 340 -480 {
lab=VSS}
N 520 -580 520 -560 {
lab=VDD}
N 1210 -680 1250 -680 {
lab=out}
N 1250 -680 1270 -680 {
lab=out}
N 620 -500 620 -480 {
lab=VSS}
N 620 -580 620 -560 {
lab=vdiff}
N 950 -720 950 -680 {
lab=vcm}
N 950 -580 950 -540 {
lab=inn}
N 950 -540 1030 -540 {
lab=inn}
N 1030 -660 1030 -540 {
lab=inn}
N 950 -820 950 -780 {
lab=inp}
N 950 -820 1030 -820 {
lab=inp}
N 1030 -820 1030 -700 {
lab=inp}
N 950 -680 950 -640 {
lab=vcm}
N 520 -480 520 -460 {
lab=VSS}
N 520 -400 520 -390 {
lab=GND}
N 380 -3000 400 -3000 {
lab=#net1}
N 560 -2980 600 -2980 {
lab=out_ac}
N 600 -2980 620 -2980 {
lab=out_ac}
N 440 -500 440 -480 {
lab=VSS}
N 440 -580 440 -560 {
lab=vac}
N 120 -2990 140 -2990 {
lab=vac}
N 120 -2950 140 -2950 {
lab=GND}
N 340 -3000 380 -3000 {
lab=#net1}
N 180 -3000 220 -3000 {
lab=#net2}
N 280 -3000 340 -3000 {
lab=#net1}
N 140 -3050 140 -3040 {
lab=GND}
N 340 -580 340 -560 {
lab=vcm}
N 180 -3100 220 -3100 {
lab=#net3}
N 280 -3100 320 -3100 {
lab=#net4}
N 360 -2860 440 -2860 {
lab=#net1}
N 500 -2860 600 -2860 {
lab=out_ac}
N 600 -2980 600 -2860 {
lab=out_ac}
N 120 -2880 140 -2880 {
lab=GND}
N 180 -2940 180 -2930 {
lab=GND}
N 120 -2920 140 -2920 {
lab=vac}
N 180 -2870 180 -2860 {
lab=#net5}
N 180 -2860 220 -2860 {
lab=#net5}
N 280 -2860 300 -2860 {
lab=#net4}
N 300 -2860 320 -2860 {
lab=#net4}
N 320 -2960 320 -2860 {
lab=#net4}
N 180 -2930 240 -2930 {
lab=GND}
N 380 -2520 400 -2520 {
lab=#net6}
N 560 -2500 600 -2500 {
lab=out_cmrr}
N 600 -2500 620 -2500 {
lab=out_cmrr}
N 120 -2510 140 -2510 {
lab=vac}
N 120 -2470 140 -2470 {
lab=GND}
N 340 -2520 380 -2520 {
lab=#net6}
N 180 -2520 220 -2520 {
lab=#net7}
N 280 -2520 340 -2520 {
lab=#net6}
N 140 -2570 140 -2560 {
lab=GND}
N 180 -2620 220 -2620 {
lab=#net8}
N 280 -2620 320 -2620 {
lab=#net9}
N 360 -2380 440 -2380 {
lab=#net6}
N 500 -2380 600 -2380 {
lab=out_cmrr}
N 600 -2500 600 -2380 {
lab=out_cmrr}
N 120 -2400 140 -2400 {
lab=GND}
N 180 -2460 180 -2450 {
lab=GND}
N 120 -2440 140 -2440 {
lab=vac}
N 180 -2390 180 -2380 {
lab=#net10}
N 180 -2380 220 -2380 {
lab=#net10}
N 280 -2380 300 -2380 {
lab=#net9}
N 300 -2380 320 -2380 {
lab=#net9}
N 320 -2480 320 -2380 {
lab=#net9}
N 180 -2450 240 -2450 {
lab=GND}
N 340 -2000 360 -2000 {
lab=vcm}
N 520 -2020 560 -2020 {
lab=out_psrr}
N 560 -2020 580 -2020 {
lab=out_psrr}
N 300 -2000 340 -2000 {
lab=vcm}
N 220 -2000 260 -2000 {
lab=vcm}
N 320 -1900 400 -1900 {
lab=out_psrr}
N 460 -1900 560 -1900 {
lab=out_psrr}
N 560 -2020 560 -1900 {
lab=out_psrr}
N 440 -2200 440 -2180 {
lab=VDD}
N 220 -2190 240 -2190 {
lab=vac}
N 220 -2150 240 -2150 {
lab=GND}
N 440 -2120 440 -2070 {
lab=#net11}
N 300 -2200 340 -2200 {
lab=#net12}
N 340 -2200 340 -2180 {
lab=#net12}
N 280 -2000 300 -2000 {
lab=vcm}
N 260 -2000 280 -2000 {
lab=vcm}
N 400 -1900 460 -1900 {
lab=out_psrr}
N 1220 -740 1220 -680 {
lab=out}
N 1250 -780 1260 -780 {
lab=VDD}
N 1260 -820 1260 -780 {
lab=VDD}
N 1220 -790 1220 -780 {
lab=VDD}
N 1220 -790 1250 -790 {
lab=VDD}
N 1250 -790 1250 -780 {
lab=VDD}
N 1120 -780 1190 -780 {
lab=#net13}
N 1120 -800 1120 -780 {
lab=#net13}
N 1120 -880 1120 -860 {
lab=VDD}
N 1120 -880 1260 -880 {
lab=VDD}
N 1260 -880 1260 -820 {
lab=VDD}
N 580 -3040 580 -2980 {
lab=out_ac}
N 610 -3080 620 -3080 {
lab=VDD}
N 620 -3120 620 -3080 {
lab=VDD}
N 580 -3090 580 -3080 {
lab=VDD}
N 580 -3090 610 -3090 {
lab=VDD}
N 610 -3090 610 -3080 {
lab=VDD}
N 480 -3080 550 -3080 {
lab=#net14}
N 480 -3100 480 -3080 {
lab=#net14}
N 480 -3180 480 -3160 {
lab=VDD}
N 480 -3180 620 -3180 {
lab=VDD}
N 620 -3180 620 -3120 {
lab=VDD}
N 580 -2560 580 -2500 {
lab=out_cmrr}
N 610 -2600 620 -2600 {
lab=VDD}
N 620 -2640 620 -2600 {
lab=VDD}
N 580 -2610 580 -2600 {
lab=VDD}
N 580 -2610 610 -2610 {
lab=VDD}
N 610 -2610 610 -2600 {
lab=VDD}
N 480 -2600 550 -2600 {
lab=#net15}
N 480 -2620 480 -2600 {
lab=#net15}
N 480 -2700 480 -2680 {
lab=VDD}
N 480 -2700 620 -2700 {
lab=VDD}
N 620 -2700 620 -2640 {
lab=VDD}
N 620 -2080 620 -2020 {
lab=out_psrr}
N 650 -2120 660 -2120 {
lab=VDD}
N 660 -2160 660 -2120 {
lab=VDD}
N 620 -2130 620 -2120 {
lab=VDD}
N 620 -2130 650 -2130 {
lab=VDD}
N 650 -2130 650 -2120 {
lab=VDD}
N 520 -2120 590 -2120 {
lab=#net16}
N 520 -2140 520 -2120 {
lab=#net16}
N 520 -2220 520 -2200 {
lab=VDD}
N 520 -2220 660 -2220 {
lab=VDD}
N 660 -2220 660 -2160 {
lab=VDD}
N 340 -2120 340 -2100 {
lab=#net11}
N 340 -2100 440 -2100 {
lab=#net11}
N 580 -2020 620 -2020 {
lab=out_psrr}
N 280 -2200 300 -2200 {
lab=#net12}
N 360 -3000 360 -2860 {
lab=#net1}
N 320 -2960 400 -2960 {
lab=#net4}
N 320 -2040 320 -1900 {
lab=out_psrr}
N 320 -2040 360 -2040 {
lab=out_psrr}
N 320 -2480 400 -2480 {
lab=#net9}
N 360 -2520 360 -2380 {
lab=#net6}
N 320 -2620 320 -2480 {
lab=#net9}
N 320 -3100 320 -2960 {
lab=#net4}
C {devices/title.sym} 170 -40 0 0 {name=l1 author="Manuel Moser"}
C {devices/simulator_commands.sym} 160 -570 0 0 {name=COMMANDS
simulator=ngspice
only_toplevel=false 
value="
.temp 27
.option gmin = 1e-16
.option RSHUNT=1E20

.param vsource = 1.8
.param vcm = \{vsource/2\}


.save all
 + @m.x1.x1.xmn1.msky130_fd_pr__nfet_01v8_lvt[vgs] @m.x1.x1.xmn1.msky130_fd_pr__nfet_01v8_lvt[vth] @m.x1.x1.xmn1.msky130_fd_pr__nfet_01v8_lvt[vds] @m.x1.x1.xmn1.msky130_fd_pr__nfet_01v8_lvt[vdsat] @m.x1.x1.xmn1.msky130_fd_pr__nfet_01v8_lvt[id] @m.x1.x1.xmn1.msky130_fd_pr__nfet_01v8_lvt[gm]
 + @m.x1.x1.xmn2.msky130_fd_pr__nfet_01v8_lvt[vgs] @m.x1.x1.xmn2.msky130_fd_pr__nfet_01v8_lvt[vth] @m.x1.x1.xmn2.msky130_fd_pr__nfet_01v8_lvt[vds] @m.x1.x1.xmn2.msky130_fd_pr__nfet_01v8_lvt[vdsat] @m.x1.x1.xmn2.msky130_fd_pr__nfet_01v8_lvt[id] @m.x1.x1.xmn2.msky130_fd_pr__nfet_01v8_lvt[gm]
 + @m.x1.x1.xmn3.msky130_fd_pr__nfet_01v8_lvt[vgs] @m.x1.x1.xmn3.msky130_fd_pr__nfet_01v8_lvt[vth] @m.x1.x1.xmn3.msky130_fd_pr__nfet_01v8_lvt[vds] @m.x1.x1.xmn3.msky130_fd_pr__nfet_01v8_lvt[vdsat] @m.x1.x1.xmn3.msky130_fd_pr__nfet_01v8_lvt[id] @m.x1.x1.xmn3.msky130_fd_pr__nfet_01v8_lvt[gm]
 + @m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[vgs] @m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[vth] @m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[vds] @m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[vdsat] @m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[id] @m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[gm]
 + @m.x1.x1.xmn5.msky130_fd_pr__nfet_01v8[vgs] @m.x1.x1.xmn5.msky130_fd_pr__nfet_01v8[vth] @m.x1.x1.xmn5.msky130_fd_pr__nfet_01v8[vds] @m.x1.x1.xmn5.msky130_fd_pr__nfet_01v8[vdsat] @m.x1.x1.xmn5.msky130_fd_pr__nfet_01v8[id] @m.x1.x1.xmn5.msky130_fd_pr__nfet_01v8[gm]
 + @m.x1.x1.xmn6.msky130_fd_pr__nfet_01v8[vgs] @m.x1.x1.xmn6.msky130_fd_pr__nfet_01v8[vth] @m.x1.x1.xmn6.msky130_fd_pr__nfet_01v8[vds] @m.x1.x1.xmn6.msky130_fd_pr__nfet_01v8[vdsat] @m.x1.x1.xmn6.msky130_fd_pr__nfet_01v8[id] @m.x1.x1.xmn6.msky130_fd_pr__nfet_01v8[gm]
 + @m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[vgs] @m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[vth] @m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[vds] @m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[vdsat] @m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[id] @m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[gm]
 + @m.x1.x1.xmp1.msky130_fd_pr__pfet_01v8_lvt[vgs] @m.x1.x1.xmp1.msky130_fd_pr__pfet_01v8_lvt[vth] @m.x1.x1.xmp1.msky130_fd_pr__pfet_01v8_lvt[vds] @m.x1.x1.xmp1.msky130_fd_pr__pfet_01v8_lvt[vdsat] @m.x1.x1.xmp1.msky130_fd_pr__pfet_01v8_lvt[id] @m.x1.x1.xmp1.msky130_fd_pr__pfet_01v8_lvt[gm]
 + @m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[vgs] @m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[vth] @m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[vds] @m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[vdsat] @m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[id] @m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[gm]
 + @m.x1.x1.xmp3.msky130_fd_pr__pfet_01v8_lvt[vgs] @m.x1.x1.xmp3.msky130_fd_pr__pfet_01v8_lvt[vth] @m.x1.x1.xmp3.msky130_fd_pr__pfet_01v8_lvt[vds] @m.x1.x1.xmp3.msky130_fd_pr__pfet_01v8_lvt[vdsat] @m.x1.x1.xmp3.msky130_fd_pr__pfet_01v8_lvt[id] @m.x1.x1.xmp3.msky130_fd_pr__pfet_01v8_lvt[gm]
 + @m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[vgs] @m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[vth] @m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[vds] @m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[vdsat] @m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[id] @m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[gm]
  
.control
set num_threads = 12
write ldo_ota_tb.raw
set appendwrite

repeat 5
 reset
 dc vd -200m 200m 0.4m temp -30 60 90
 
write ldo_ota_tb.raw out x1.bias1 x1.bias2 x1.bias3 x1.bias4
 + @m.x1.x1.xmn1.msky130_fd_pr__nfet_01v8_lvt[vgs] @m.x1.x1.xmn1.msky130_fd_pr__nfet_01v8_lvt[vth] @m.x1.x1.xmn1.msky130_fd_pr__nfet_01v8_lvt[vds] @m.x1.x1.xmn1.msky130_fd_pr__nfet_01v8_lvt[vdsat] @m.x1.x1.xmn1.msky130_fd_pr__nfet_01v8_lvt[id] @m.x1.x1.xmn1.msky130_fd_pr__nfet_01v8_lvt[gm]
 + @m.x1.x1.xmn2.msky130_fd_pr__nfet_01v8_lvt[vgs] @m.x1.x1.xmn2.msky130_fd_pr__nfet_01v8_lvt[vth] @m.x1.x1.xmn2.msky130_fd_pr__nfet_01v8_lvt[vds] @m.x1.x1.xmn2.msky130_fd_pr__nfet_01v8_lvt[vdsat] @m.x1.x1.xmn2.msky130_fd_pr__nfet_01v8_lvt[id] @m.x1.x1.xmn2.msky130_fd_pr__nfet_01v8_lvt[gm]
 + @m.x1.x1.xmn3.msky130_fd_pr__nfet_01v8_lvt[vgs] @m.x1.x1.xmn3.msky130_fd_pr__nfet_01v8_lvt[vth] @m.x1.x1.xmn3.msky130_fd_pr__nfet_01v8_lvt[vds] @m.x1.x1.xmn3.msky130_fd_pr__nfet_01v8_lvt[vdsat] @m.x1.x1.xmn3.msky130_fd_pr__nfet_01v8_lvt[id] @m.x1.x1.xmn3.msky130_fd_pr__nfet_01v8_lvt[gm]
 + @m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[vgs] @m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[vth] @m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[vds] @m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[vdsat] @m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[id] @m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[gm]
 + @m.x1.x1.xmn5.msky130_fd_pr__nfet_01v8[vgs] @m.x1.x1.xmn5.msky130_fd_pr__nfet_01v8[vth] @m.x1.x1.xmn5.msky130_fd_pr__nfet_01v8[vds] @m.x1.x1.xmn5.msky130_fd_pr__nfet_01v8[vdsat] @m.x1.x1.xmn5.msky130_fd_pr__nfet_01v8[id] @m.x1.x1.xmn5.msky130_fd_pr__nfet_01v8[gm]
 + @m.x1.x1.xmn6.msky130_fd_pr__nfet_01v8[vgs] @m.x1.x1.xmn6.msky130_fd_pr__nfet_01v8[vth] @m.x1.x1.xmn6.msky130_fd_pr__nfet_01v8[vds] @m.x1.x1.xmn6.msky130_fd_pr__nfet_01v8[vdsat] @m.x1.x1.xmn6.msky130_fd_pr__nfet_01v8[id] @m.x1.x1.xmn6.msky130_fd_pr__nfet_01v8[gm]
 + @m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[vgs] @m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[vth] @m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[vds] @m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[vdsat] @m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[id] @m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[gm]
 + @m.x1.x1.xmp1.msky130_fd_pr__pfet_01v8_lvt[vgs] @m.x1.x1.xmp1.msky130_fd_pr__pfet_01v8_lvt[vth] @m.x1.x1.xmp1.msky130_fd_pr__pfet_01v8_lvt[vds] @m.x1.x1.xmp1.msky130_fd_pr__pfet_01v8_lvt[vdsat] @m.x1.x1.xmp1.msky130_fd_pr__pfet_01v8_lvt[id] @m.x1.x1.xmp1.msky130_fd_pr__pfet_01v8_lvt[gm]
 + @m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[vgs] @m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[vth] @m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[vds] @m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[vdsat] @m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[id] @m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[gm]
 + @m.x1.x1.xmp3.msky130_fd_pr__pfet_01v8_lvt[vgs] @m.x1.x1.xmp3.msky130_fd_pr__pfet_01v8_lvt[vth] @m.x1.x1.xmp3.msky130_fd_pr__pfet_01v8_lvt[vds] @m.x1.x1.xmp3.msky130_fd_pr__pfet_01v8_lvt[vdsat] @m.x1.x1.xmp3.msky130_fd_pr__pfet_01v8_lvt[id] @m.x1.x1.xmp3.msky130_fd_pr__pfet_01v8_lvt[gm]
 + @m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[vgs] @m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[vth] @m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[vds] @m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[vdsat] @m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[id] @m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[gm]
 
 ac dec 10 1 10meg
 write ldo_ota_tb.raw out_ac out_cmrr out_psrr

 op
 write ldo_ota_tb.raw

end

.endc
"}
C {sky130_fd_pr/corner.sym} 20 -570 0 0 {name=CORNER only_toplevel=false corner=mc}
C {devices/vsource.sym} 340 -530 0 0 {name=V1 value=vcm}
C {devices/vsource.sym} 620 -530 0 0 {name=Vd value="0"}
C {devices/vsource.sym} 520 -530 0 0 {name=Vsrc value=vsource}
C {devices/lab_wire.sym} 520 -580 0 1 {name=p9 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 520 -480 2 1 {name=p1 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1130 -730 0 1 {name=p2 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1130 -630 2 1 {name=p3 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 340 -480 2 1 {name=p4 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1250 -680 0 1 {name=p5 sig_type=std_logic lab=out}
C {devices/lab_wire.sym} 620 -480 2 1 {name=p6 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 620 -580 0 1 {name=p7 sig_type=std_logic lab=vdiff}
C {devices/vcvs.sym} 950 -750 0 1 {name=E2 value=0.5}
C {devices/vcvs.sym} 950 -610 0 1 {name=E3 value=0.5}
C {devices/lab_wire.sym} 990 -770 0 1 {name=p8 sig_type=std_logic lab=vdiff}
C {devices/lab_wire.sym} 990 -730 0 1 {name=p10 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 990 -590 2 0 {name=p11 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 990 -630 2 0 {name=p12 sig_type=std_logic lab=vdiff}
C {devices/lab_wire.sym} 970 -820 0 1 {name=p14 sig_type=std_logic lab=inp}
C {devices/lab_wire.sym} 970 -540 0 1 {name=p15 sig_type=std_logic lab=inn}
C {devices/vsource.sym} 520 -430 0 0 {name=Vgnd value=0}
C {devices/gnd.sym} 520 -390 0 0 {name=l3 lab=GND}
C {ldo_ota.sym} 480 -2980 0 0 {name=x2}
C {devices/lab_wire.sym} 480 -3030 0 1 {name=p13 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 480 -2930 2 1 {name=p16 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 600 -2980 0 1 {name=p18 sig_type=std_logic lab=out_ac}
C {devices/launcher.sym} 1250 -1820 0 0 {name=h2
descr="load dc results.raw" 
tclcommand="xschem raw_read $netlist_dir/ldo_ota_tb.raw dc"
}
C {devices/launcher.sym} 1250 -1790 0 0 {name=h3
descr="load ac results.raw" 
tclcommand="xschem raw_read $netlist_dir/ldo_ota_tb.raw ac"
}
C {devices/vsource.sym} 440 -530 0 0 {name=Va value="0 ac 1"}
C {devices/lab_wire.sym} 440 -480 2 1 {name=Vac1 sig_type=std_logic lab=VSS
value="0 ac 1"}
C {devices/lab_wire.sym} 440 -580 0 1 {name=Vac2 sig_type=std_logic lab=vac
value="0 ac 1"}
C {devices/vcvs.sym} 180 -2970 0 0 {name=E1 value=0.5}
C {devices/lab_wire.sym} 120 -2990 0 0 {name=Vac3 sig_type=std_logic lab=vac
value="0 ac 1"}
C {devices/gnd.sym} 120 -2950 0 0 {name=l5 lab=GND}
C {devices/capa.sym} 250 -3000 3 1 {name=C1
m=1
value=1e6
footprint=1206
device="ceramic capacitor"}
C {devices/ind.sym} 250 -3100 1 0 {name=L7
m=1
value=1e18
footprint=1206
device=inductor}
C {devices/vcvs.sym} 180 -3070 0 0 {name=E4 value=1}
C {devices/gnd.sym} 180 -3040 0 0 {name=l8 lab=GND}
C {devices/gnd.sym} 140 -3040 0 0 {name=l9 lab=GND}
C {devices/lab_wire.sym} 340 -580 0 0 {name=p17 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 950 -680 0 0 {name=p19 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 140 -3090 0 0 {name=p20 sig_type=std_logic lab=vcm}
C {devices/ind.sym} 470 -2860 1 0 {name=L10
m=1
value=1e18
footprint=1206
device=inductor}
C {devices/vcvs.sym} 180 -2900 0 0 {name=E5 value=0.5}
C {devices/gnd.sym} 120 -2880 0 0 {name=l6 lab=GND}
C {devices/lab_wire.sym} 120 -2920 0 0 {name=Vac4 sig_type=std_logic lab=vac
value="0 ac 1"}
C {devices/capa.sym} 250 -2860 3 1 {name=C2
m=1
value=1e6
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 240 -2930 0 0 {name=l11 lab=GND}
C {ldo_ota.sym} 480 -2500 0 0 {name=x3}
C {devices/lab_wire.sym} 480 -2550 0 1 {name=p21 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 480 -2450 2 1 {name=p22 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 600 -2500 0 1 {name=p23 sig_type=std_logic lab=out_cmrr}
C {devices/vcvs.sym} 180 -2490 0 0 {name=E6 value=0.5}
C {devices/lab_wire.sym} 120 -2510 0 0 {name=Vac5 sig_type=std_logic lab=vac
value="0 ac 1"}
C {devices/gnd.sym} 120 -2470 0 0 {name=l13 lab=GND}
C {devices/capa.sym} 250 -2520 3 1 {name=C3
m=1
value=1e6
footprint=1206
device="ceramic capacitor"}
C {devices/ind.sym} 250 -2620 1 0 {name=L14
m=1
value=1e18
footprint=1206
device=inductor}
C {devices/vcvs.sym} 180 -2590 0 0 {name=E7 value=1}
C {devices/gnd.sym} 180 -2560 0 0 {name=l15 lab=GND}
C {devices/gnd.sym} 140 -2560 0 0 {name=l16 lab=GND}
C {devices/lab_wire.sym} 140 -2610 0 0 {name=p24 sig_type=std_logic lab=vcm}
C {devices/ind.sym} 470 -2380 1 0 {name=L17
m=1
value=1e18
footprint=1206
device=inductor}
C {devices/vcvs.sym} 180 -2420 0 0 {name=E8 value=-0.5}
C {devices/gnd.sym} 120 -2400 0 0 {name=l18 lab=GND}
C {devices/lab_wire.sym} 120 -2440 0 0 {name=Vac6 sig_type=std_logic lab=vac
value="0 ac 1"}
C {devices/capa.sym} 250 -2380 3 1 {name=C4
m=1
value=1e6
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 240 -2450 0 0 {name=l19 lab=GND}
C {ldo_ota.sym} 440 -2020 0 0 {name=x4}
C {devices/lab_wire.sym} 440 -2200 0 1 {name=p25 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 440 -1970 2 1 {name=p26 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 530 -2020 0 1 {name=p27 sig_type=std_logic lab=out_psrr}
C {devices/capa.sym} 340 -2150 0 0 {name=C5
m=1
value=1e6
footprint=1206
device="ceramic capacitor"}
C {devices/lab_wire.sym} 220 -2000 0 0 {name=p28 sig_type=std_logic lab=vcm}
C {devices/ind.sym} 440 -2150 2 0 {name=L28
m=1
value=1e18
footprint=1206
device=inductor}
C {devices/vcvs.sym} 280 -2170 0 0 {name=E12 value=1}
C {devices/lab_wire.sym} 220 -2190 0 0 {name=Vac9 sig_type=std_logic lab=vac
value="0 ac 1"}
C {devices/gnd.sym} 220 -2150 0 0 {name=l29 lab=GND}
C {devices/lab_wire.sym} 1260 -820 0 1 {name=p29 sig_type=std_logic lab=VDD}
C {devices/vsource.sym} 1120 -830 0 0 {name=Vdddrop value=100m}
C {devices/lab_wire.sym} 620 -3120 0 1 {name=p30 sig_type=std_logic lab=VDD}
C {devices/vsource.sym} 480 -3130 0 0 {name=Vdddrop1 value=100m}
C {devices/lab_wire.sym} 620 -2640 0 1 {name=p31 sig_type=std_logic lab=VDD}
C {devices/vsource.sym} 480 -2650 0 0 {name=Vdddrop2 value=100m}
C {devices/lab_wire.sym} 660 -2160 0 1 {name=p32 sig_type=std_logic lab=VDD}
C {devices/vsource.sym} 520 -2170 0 0 {name=Vdddrop3 value=100m}
C {devices/gnd.sym} 280 -2140 0 0 {name=l2 lab=GND}
C {ldo_ota.sym} 1130 -680 0 0 {name=x1}
C {sky130_fd_pr/pfet_01v8_hvt_nf.sym} 1220 -760 1 1 {name=M7
L=0.15
W=5
nf=10
mult=8
ad="'int((nf+1)/2) * W / nf * 0.29'"
pd="'2*int((nf+1)/2) * (W / nf + 0.29)'"
as="'int((nf+2)/2) * W / nf * 0.29'"
ps="'2*int((nf+2)/2) * (W / nf + 0.29)'"
nrd="'0.29 / W '" nrs="'0.29 / W '"
sa=0 sb=0 sd=0
model=pfet_01v8_hvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_hvt_nf.sym} 620 -2100 1 1 {name=M1
L=0.15
W=5
nf=5
mult=9
ad="'int((nf+1)/2) * W / nf * 0.29'"
pd="'2*int((nf+1)/2) * (W / nf + 0.29)'"
as="'int((nf+2)/2) * W / nf * 0.29'"
ps="'2*int((nf+2)/2) * (W / nf + 0.29)'"
nrd="'0.29 / W '" nrs="'0.29 / W '"
sa=0 sb=0 sd=0
model=pfet_01v8_hvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_hvt_nf.sym} 580 -2580 1 1 {name=M3
L=0.15
W=5
nf=5
mult=9
ad="'int((nf+1)/2) * W / nf * 0.29'"
pd="'2*int((nf+1)/2) * (W / nf + 0.29)'"
as="'int((nf+2)/2) * W / nf * 0.29'"
ps="'2*int((nf+2)/2) * (W / nf + 0.29)'"
nrd="'0.29 / W '" nrs="'0.29 / W '"
sa=0 sb=0 sd=0
model=pfet_01v8_hvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_hvt_nf.sym} 580 -3060 1 1 {name=M2
L=0.15
W=5
nf=5
mult=9
ad="'int((nf+1)/2) * W / nf * 0.29'"
pd="'2*int((nf+1)/2) * (W / nf + 0.29)'"
as="'int((nf+2)/2) * W / nf * 0.29'"
ps="'2*int((nf+2)/2) * (W / nf + 0.29)'"
nrd="'0.29 / W '" nrs="'0.29 / W '"
sa=0 sb=0 sd=0
model=pfet_01v8_hvt
spiceprefix=X
}
C {devices/launcher.sym} 980 -1790 0 0 {name=h1
descr="Annotate OP" 
tclcommand="set show_hidden_texts 1; xschem annotate_op"
}
C {devices/launcher.sym} 980 -1820 0 0 {name=h4
descr="View OP Raw file" 
tclcommand="textwindow $netlist_dir/[file tail [file rootname [ xschem get schname 0 ] ] ].raw"
}
C {devices/ngspice_get_value.sym} 1120 -1600 0 0 {name=r2 node=v(@m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 1120 -1570 0 0 {name=r1 node=@m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[gm]
descr="gm="}
C {devices/ngspice_get_value.sym} 1120 -1420 0 0 {name=r3 node=v(@m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 1120 -1390 0 0 {name=r4 node=@m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[gm]
descr="gm="}
C {devices/ngspice_get_value.sym} 1120 -1250 0 0 {name=r5 node=v(@m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 1120 -1220 0 0 {name=r6 node=@m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[gm]
descr="gm="}
C {devices/ngspice_get_value.sym} 1120 -1090 0 0 {name=r7 node=v(@m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[vth])
descr="vth="}
C {devices/ngspice_get_value.sym} 1120 -1060 0 0 {name=r8 node=@m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[gm]
descr="gm="}
C {devices/ngspice_get_value.sym} 1120 -1630 0 0 {name=r10 node=v(@m.x1.x1.xmp2.msky130_fd_pr__pfet_01v8_lvt[vgs])
descr="vgs="}
C {devices/ngspice_get_value.sym} 1120 -1450 0 0 {name=r11 node=v(@m.x1.x1.xmp4.msky130_fd_pr__pfet_01v8_lvt[vgs])
descr="vgs="}
C {devices/ngspice_get_value.sym} 1120 -1280 0 0 {name=r12 node=v(@m.x1.x1.xmn4.msky130_fd_pr__nfet_01v8_lvt[vgs])
descr="vgs="}
C {devices/ngspice_get_value.sym} 1120 -1120 0 0 {name=r13 node=v(@m.x1.x1.xmn7.msky130_fd_pr__nfet_01v8[vgs])
descr="vgs="}
C {devices/launcher.sym} 1250 -1760 0 0 {name=h5
descr="load op results.raw" 
tclcommand="xschem raw_read $netlist_dir/ldo_ota_tb.raw op"
}
